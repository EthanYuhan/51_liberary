# Keil uVision project CAMERA.uvproj, settings and files
target SRAM (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: CAMERA +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\GUI\font;..\GUI;..\HARDWARE\lcd;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\sd;..\HARDWARE\spi;..\FATFS;..\OV7670;..\HARDWARE\sram
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/lcd/: LCD.c
    ../HARDWARE/sd/: sd.c
    ../HARDWARE/spi/: spi.c
    ../HARDWARE/sram/: sram.c
  group GUI
    ../GUI/: gui.c
  group FATFS
    ../FATFS/: diskio.c pff.c
  group OV7670
    ../OV7670/: ov7670.c sccb.c
  group README
    ../: README.TXT
