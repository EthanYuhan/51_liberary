# Keil uVision project MP3.uvproj, settings and files
target MP3 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: MP3_single +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\GUI\font;..\GUI;..\HARDWARE\lcd;..\HARDWARE\touch;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\ad;..\HARDWARE\pca;..\HARDWARE\eeprom;..\HARDWARE\ds1302;..\HARDWARE\sd;..\HARDWARE\spi;..\FATFS;..\HARDWARE\vs1053;..\HARDWARE\mp3player
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/lcd/: LCD.c
    ../HARDWARE/eeprom/: I2C.c
    ../HARDWARE/sd/: sd.c
    ../HARDWARE/spi/: spi.c
    ../HARDWARE/vs1053/: vs1053.c
    ../HARDWARE/mp3player/: mp3player.c
  group GUI
    ../GUI/: gui.c
  group FATFS
    ../FATFS/: diskio.c pff.c
  group README
    ../: README.TXT
