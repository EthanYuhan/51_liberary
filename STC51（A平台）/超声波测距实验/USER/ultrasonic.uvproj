# Keil uVision project ultrasonic.uvproj, settings and files
target TFT (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: cltra +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\GUI\font;..\GUI;..\HARDWARE\lcd;..\HARDWARE\touch;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\uart
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/lcd/: LCD.c
    ../HARDWARE/touch/: GT911.c GTIIC.c touch.c
    ../HARDWARE/uart/: uart.c
  group GUI
    ../GUI/: gui.c
  group README
    ../: README.TXT
