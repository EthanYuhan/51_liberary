# Keil uVision project Lift.uvproj, settings and files
target Lift (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2019 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\README;..\HARDWARE\lcd12864;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\key;..\HARDWARE\motor;..\HARDWARE\timer
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/key/: key.c
    ../HARDWARE/lcd12864/: lcd12864.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/timer/: timer.c
  group README
    ../README/: README.TXT
