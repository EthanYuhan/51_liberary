# Keil uVision project PWM.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0EFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: PWM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\HARDWARE\pwm;..\SYSTEM\sys
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/pwm/: PWM.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group README
    ../: README.TXT
