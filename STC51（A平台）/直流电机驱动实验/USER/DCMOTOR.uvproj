# Keil uVision project DCMOTOR.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: DCmotor +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./: main.c
  group README
    ../: README.TXT
