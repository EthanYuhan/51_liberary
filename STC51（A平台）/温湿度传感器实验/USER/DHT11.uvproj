# Keil uVision project DHT11.uvproj, settings and files
target DHT11 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: DHT11 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\GUI\font;..\GUI;..\HARDWARE\lcd;..\HARDWARE\touch;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\ad;..\HARDWARE\pca;..\HARDWARE\eeprom;..\HARDWARE\ds18b20;..\HARDWARE\dht11
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/lcd/: LCD.c
    ../HARDWARE/touch/: GT911.c GTIIC.c touch.c
    ../HARDWARE/eeprom/: I2C.c
    ../HARDWARE/dht11/: DHT11.c
  group GUI
    ../GUI/: gui.c
  group README
    ../: README.TXT
