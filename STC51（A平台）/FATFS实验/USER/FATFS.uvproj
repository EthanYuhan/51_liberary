# Keil uVision project FATFS.uvproj, settings and files
target FATFS (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: FATFS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\GUI\font;..\GUI;..\HARDWARE\lcd;..\HARDWARE\touch;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\ad;..\HARDWARE\pca;..\HARDWARE\eeprom;..\HARDWARE\ds1302;..\HARDWARE\sd;..\HARDWARE\spi;..\FATFS
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/lcd/: LCD.c
    ../HARDWARE/touch/: GT911.c GTIIC.c touch.c
    ../HARDWARE/ad/: ad.c
    ../HARDWARE/sd/: sd.c
    ../HARDWARE/spi/: spi.c
  group GUI
    ../GUI/: gui.c
  group FATFS
    ../FATFS/: diskio.c pff.c
  group README
    ../: README.TXT
