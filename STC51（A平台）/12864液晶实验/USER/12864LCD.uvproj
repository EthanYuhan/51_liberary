# Keil uVision project 12864LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\README
  group USER
    ./: main.c lcd12864.c
  group README
    ../README/: README.TXT
