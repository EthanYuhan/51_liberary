# Keil uVision project LD3320.uvproj, settings and files
target LD3320 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LD3320 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\GUI\font;..\GUI;..\HARDWARE\lcd;..\HARDWARE\touch;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\ad;..\HARDWARE\pca;..\HARDWARE\eeprom;..\HARDWARE\ds1302;..\HARDWARE\sd;..\HARDWARE\spi;..\HARDWARE\w5500;..\HARDWARE\uart;..\HARDWARE\ld3320
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/spi/: spi.c
    ../HARDWARE/uart/: uart.c
    ../HARDWARE/ld3320/: LD3320.c ld3320_test.c
  group README
    ../: readme.txt
