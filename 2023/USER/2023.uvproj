# Keil uVision project 2023.uvproj, settings and files
target TEST (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2023 +hex
  c flags: Optimize=8
  c include: ..\USER;..\README;..\HARDWARE\lcd12864;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\key;..\HARDWARE\motor;..\HARDWARE\timer;..\HARDWARE\ad;..\HARDWARE\ds1302;..\HARDWARE\interrupt;..\HARDWARE\dht11;..\HARDWARE\eeprom;..\HARDWARE\interrupt;..\HARDWARE\motor;..\HARDWARE\mpu6050;..\HARDWARE\hx711
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/key/: key.c
    ../HARDWARE/lcd12864/: lcd12864.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/ad/: ad.c
    ../HARDWARE/ds1302/: ds1302.c
    ../HARDWARE/dht11/: dht11.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/mpu6050/: mpu6050.c
    ../HARDWARE/hx711/: hx711.c
