# Keil uVision project 5-10.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 5-10 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\ad;..\HARDWARE\ds1302;..\HARDWARE\key;..\HARDWARE\lcd12864;..\HARDWARE\timer;..\SYSTEM\sys
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/ad/: ad.c
    ../HARDWARE/ds1302/: ds1302.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/lcd12864/: lcd12864.c
    ../HARDWARE/timer/: timer.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
